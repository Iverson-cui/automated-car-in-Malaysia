# Keil uVision project oled_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: forward +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
  group driver
    ../../../TJUFINAL/TJUFINAL/TJUcoding/: driver.h
    ./: driver.c
  group tracking
    ../../../TJUFINAL/TJUFINAL/TJUcoding/: tracking.c tracking.h
